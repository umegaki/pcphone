# Repository umegaki/pcphone

File README.md:

# PCPhone とは
* PC Phone is a telephone assist device for physical disabilities. 
* PCホンは、肢体不自由のために固定電話機の操作ができない人が、PCから固定電話を操作できるようにするデバイスです。
* 原則として、オープンハードウェアとして公開していますが、ライセンス条件は、まだ書きかけです。変更される可能性があります。

# 構成

次の3つで構成されます。

1. 固定電話機（要改造）
2. PcPhone Arduino コントローラ
3. PcPhone Windows アプリケーション

# 注意喚起

電話機とコントローラの接続には電話機の改造が必要になります。このような改造は、技術基準適合認定（*技適*）に違反することになります。特に、電波を発する機器の場合には、その運用はより厳しくなります。したがって、通信回線にかかわる部分を改造しない、無線を搭載した固定電話機を使用しない、直接電話回線網に接続せず ONUやルーターを介して接続する、という点に注意を払いました。しかし、改造それ自体は違法とされる可能性のある行為です。今回は、障害者が回線を使えなければ利用できないサービスがあることを前提にして、電気通信事業法の趣旨を尊重しつつ、障害者の情報アクセスの権利を確保するにはやむをえないと判断しました。本機のユーザは、サービスを利用できない旨を当該運営会社に連絡し対応策を求めました。当該企業の担当者はそのユーザを訪問し現状を把握しましたが、今のところ対応策はないという結論でした。その後、ユーザから作者に相談を持ち掛けられました。

サービスを提供する運営会社は、障害者がサービスを利用できない状態であることに対して苦情を申し立てているのですから、合理的配慮に基づいた対策をすべきであり、それが本来行われるべき対策です。本機の開発はそのようなサポート不在に対するやむを得ない解決策であったことも付け加えておきます。

また、作者は、アナログ第2種工事担当者資格（旧電話工事資格）を持っており、その責任において、回線網に影響を与えないよう十分に配慮して設計しました。

作者は、このように不法性を問われるリスクを冒すことを問題なしとは考えません。障害者に対する合理的配慮の欠如によって生じる問題であり、このようなデバイスは本来必要なものではないし、またその制作を推進する立場にもありません。ここで公開する情報を利用して何らかの機器開発を行うときには、ここで述べた事項について自身の責任において実施してください。

#  PcPhone Arduino コントローラ

PCからのコマンドを受け付けて、電話機のボタンを押すための制御部です。

* Arduino nano R3 を用いました。
* 電話機の0～9、#*、ハンズフリ－の各ボタンの配線を確認して、それらをリレーを用いてオンすることによって、電話をかけることができる構造です。
* PCとの通信は、Arduino の USB と統合された仮想シリアルポートを通じて行います。
* リレーの個数を節約するために、電話機のボタンをスキャンする信号 COL、ROW を個別にオンします。この仕様は、電話機のボタンのスキャン方式に依存します。
* 半導体スイッチではなくメカニカルリレーを使用した理由は、できるだけ電話機本体と疎結合にすること、サージなどの影響を受けても発火・感電事故などが起きにくくするためです。
* 電話機との接続には、14ピンのフラットケーブルを使用していますが、ケーブルやボックスヘッダーが秋月電子通商で安価に購入できることが理由です。
* タカチ電機工業 LC型ハンドタイププラスチックケース(オフホワイト) LC135H-N-W に収まるようにJLCPCBでプリント基板を製造しました。

# PcPhone Windows アプリケーション

* USB 仮想シリアルポートを介して、コントローラにコマンド文字を送信することで、電話機を操作します。

# 固定電話機

* シンプルシニアホン ブラック_TEL-2991SO-K 05-2991 （オーム電機）を使用しました。 [https://www.ohm-electric.co.jp/product/c17/c1704/37945/]
* 国産で、技適があり、アダプタ不要で回線だけで動作する、ハンズフリー機能のあるものを選択しました。
* この電話機の制御には、Silan Semiconductor 社の SC91415 が使用されています。
* ここにデータシートがあります。[https://www.digchip.com/datasheets/parts/datasheet/433/SC91415-pdf.php]

# ファイルの説明

* Pc-Phone.kicad_pcb KiCADの基板データ
* PcPhone.kicad_sch KiCADの回路図、PcPhone_sch.pdf 回路図のPDF
* PcPhoneBOM.csv 部品表
* pcphone-arduino.ino Arduinoプログラムソースコード

基板データは、Arduino D0 D1 を D12 D11 に変更する前のものです。そのまま使用するときは、基板のパターン2本をカットして、ジャンパーで修正する必要があります。
Windowsアプリケーションのソースコードは、準備できましたら公開します。

# 作者について
* この公開情報は、[https://github.com/umegaki/pcphone/] です。
* 作者のサイトは、[https://www.umegaki.jp/] です。

## KiCad design Pc-Phone.kicad_pcb

Parts:
A1: ‎Hailege ‎H-A-1714; Arduino_Nano
C1: 0.1; C_Disc_D3.0mm_W1.6mm_P2.50mm
C2, C4: 47uF; CP_Radial_D8.0mm_P3.80mm
C3: 100uF; CP_Radial_D8.0mm_P3.80mm
D1, D2, D3, D4, D5, D6, D7, D8, D11: LED; LED_D3.0mm
J1, J10: Conn_02x07_Odd_Even; IDC-Header_2x07_P2.54mm_Horizontal
J3: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J11: Conn_02x07_Odd_Even; IDC-Header_2x07_P2.54mm_Vertical
K1, K2, K3, K4, K5, K6, K7, K8: G5V-2; Relay_DPDT_Omron_G5V-2
Q11: 2SC1815; TO-92_Inline
R1, R2, R3, R4, R5, R6, R7, R8, R12: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
R9, R13, R14, R15, R16: 1; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
R10, R11: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
RN1: R_Network08; R_Array_SIP9
TP1: COMMON; Pin_D1.0mm_L10.0mm
TP2: R1; Pin_D1.0mm_L10.0mm
TP3: R2; Pin_D1.0mm_L10.0mm
TP4, TP9, TP10: R3; Pin_D1.0mm_L10.0mm
TP5: R4; Pin_D1.0mm_L10.0mm
TP6, TP7: C1; Pin_D1.0mm_L10.0mm
TP8: C3; Pin_D1.0mm_L10.0mm
U1: TD62083AFG; DIP-18_W7.62mm
U2: LM7805_TO220; TO-220-3_Vertical

Connections:
+5V: C1.1, C2.1, C3.1, K1.16, K2.16, K3.16, K4.16, K5.16, K6.16, K7.16, K8.16, R1.1, R2.1, R3.1, R4.1, R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R12.1, R13.2, R14.2, R15.2, R16.2, RN1.1 (common), TP10.1, U1.10 (COM)
/+5VO: R9.1, U2.3 (VO)
/C1: J1.2, K5.8, K5.9, TP6.1
/C2: J1.4, K6.8, K6.9, TP7.1
/C3: J1.6, K7.8, K7.9, TP8.1
/D0: A1.2 (D0/RX), U1.1 (I1)
/D1: A1.1 (D1/TX), U1.2 (I2)
/D2: A1.5 (D2), U1.3 (I3)
/D3: A1.6 (D3), U1.4 (I4)
/D4: A1.7 (D4), U1.5 (I5)
/D5: A1.8 (D5), U1.6 (I6)
/D6: A1.9 (D6), U1.7 (I7)
/D7: A1.10 (D7), U1.8 (I8)
/DR0: D1.1 (K), K1.1, U1.18 (O1)
/DR1: D2.1 (K), K2.1, U1.17 (O2)
/DR2: D3.1 (K), K3.1, U1.16 (O3)
/DR3: D4.1 (K), K4.1, U1.15 (O4)
/DR4: D5.1 (K), K5.1, U1.14 (O5)
/DR5: D6.1 (K), K6.1, U1.13 (O6)
/DR6: D7.1 (K), K7.1, U1.12 (O7)
/DR7: D8.1 (K), K8.1, U1.11 (O8)
/HF: J1.14, K8.4, K8.13
/LED: A1.16 (D13), R11.1
/R1: J1.1, K1.8, K1.9, TP2.1
/R2: J1.3, K2.8, K2.9, TP3.1
/R3: J1.5, K3.8, K3.9, TP4.1
/R4: J1.7, K4.8, K4.9, TP5.1
/VIN: C4.1, J3.1, U2.1 (VI)
/VSS: J1.13, K8.8, K8.9
GND: A1.4 (GND), A1.29 (GND), C1.2, C2.2, C3.2, C4.2, J3.2, Q11.1 (E), TP9.1, U1.9 (GND), U2.2 (GND)
unnamed: A1.27 (+5V), R13.1, R14.1, R15.1, R16.1
unnamed: A1.19 (A0), RN1.2 (R1)
unnamed: A1.20 (A1), RN1.3 (R2)
unnamed: A1.21 (A2), RN1.4 (R3)
unnamed: A1.22 (A3), RN1.5 (R4)
unnamed: A1.23 (A4), RN1.6 (R5)
unnamed: A1.24 (A5), RN1.7 (R6)
unnamed: A1.25 (A6), RN1.8 (R7)
unnamed: A1.26 (A7), RN1.9 (R8)
unnamed: A1.18 (AREF), R10.1
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.2 (A), R4.2
unnamed: D5.2 (A), R5.1
unnamed: D6.2 (A), R6.1
unnamed: D7.2 (A), R7.1
unnamed: D8.2 (A), R8.1
unnamed: D11.2 (A), R12.2
unnamed: D11.1 (K), Q11.2 (C)
unnamed: J10.1, J11.1
unnamed: J10.2, J11.2
unnamed: J10.3, J11.3
unnamed: J10.4, J11.4
unnamed: J10.5, J11.5
unnamed: J10.6, J11.6
unnamed: J10.7, J11.7
unnamed: J10.8, J11.8
unnamed: J10.9, J11.9
unnamed: J10.10, J11.10
unnamed: J10.11, J11.11
unnamed: J10.12, J11.12
unnamed: J10.13, J11.13
unnamed: J10.14, J11.14
unnamed: K1.4, K1.13, K2.4, K2.13, K3.4, K3.13, K4.4, K4.13, K5.4, K5.13, K6.4, K6.13, K7.4, K7.13, TP1.1
unnamed: Q11.3 (B), R11.2

Notes on the sheet:
電話機側接続コネクタ
HANDS FREE
Nano 3.0 ATmega328P Type-C USB CH340 コントローラー ボード

Board: 2 copper layers, 66.0 x 141.4 mm, 56 parts (0 on the bottom side), 66 nets.

File PcPhoneBOM.csv:

Reference,Qty,Value,Footprint,Datasheet
A1,1,‎Hailege ‎H-A-1714,Module:Arduino_Nano,http://www.mouser.com/pdfdocs/Gravitech_Arduino_Nano3_0.pdf
C1,1,0.1,Capacitor_THT:C_Disc_D3.0mm_W1.6mm_P2.50mm,~
"C2,C4",2,47uF,Capacitor_THT:CP_Radial_D8.0mm_P3.80mm,~
C3,1,100uF,Capacitor_THT:CP_Radial_D8.0mm_P3.80mm,~
"D1,D2,D3,D4,D5,D6,D7,D8,D11",9,LED,LED_THT:LED_D3.0mm,~
"J1,J10",2,Conn_02x07_Odd_Even,Connector_IDC:IDC-Header_2x07_P2.54mm_Horizontal,~
J3,1,Conn_01x02,Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical,~
J11,1,Conn_02x07_Odd_Even,Connector_IDC:IDC-Header_2x07_P2.54mm_Vertical,~
"K1,K2,K3,K4,K5,K6,K7,K8",8,G5V-2,Relay_THT:Relay_DPDT_Omron_G5V-2,http://omronfs.omron.com/en_US/ecb/products/pdf/en-g5v_2.pdf
Q11,1,2SC1815,Package_TO_SOT_THT:TO-92_Inline,https://media.digikey.com/pdf/Data%20Sheets/Toshiba%20PDFs/2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
"R1,R2,R3,R4,R5,R6,R7,R8,R12",9,1K,Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical,~
"R9,R13,R14,R15,R16",5,1,Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical,~
"R10,R11",2,10K,Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical,~
RN1,1,R_Network08,Resistor_THT:R_Array_SIP9,http://www.vishay.com/docs/31509/csc.pdf
U1,1,TD62083AFG,Package_DIP:DIP-18_W7.62mm,http://www.promelec.ru/pdf/1536.pdf
U2,1,LM7805_TO220,Package_TO_SOT_THT:TO-220-3_Vertical,https://www.onsemi.cn/PowerSolutions/document/MC7800-D.PDF

## Commit log

2026-04-24 Add Japanese description for PC Phone
2026-04-24 Fix typo in qualifications description
2026-04-24 Add files via upload
    KiCAD 回路図
2026-04-24 Add files via upload
    KiCAD PCB 設計データ
2026-04-24 Update BOM entries in PcPhoneBOM.csv
    Replaced the existing BOM entries with updated values while maintaining the same structure.
2026-04-27 Add LICENSE file
2026-04-27 Update copyright year and owner in LICENSE file
2026-04-27 Fix punctuation in README description
2026-04-27 Remove licensing note from README
    Removed a line about licensing conditions.
2026-04-27 Rename project to 'PCPhone' and update description
    Updated project name and description in README.
